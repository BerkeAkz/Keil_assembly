# Keil uVision project hoca_cıkmıs_soru_cjne.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: hoca_cıkmıs_soru_cjne
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 hoca_cıkmıs_soru_cjne.a51
