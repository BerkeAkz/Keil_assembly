ORG 0000H
	

MOV 30H, #001H
MOV 31H, #002H
MOV 32H, #003H
MOV 33H, #004H
MOV 34H, #005H
MOV 35H, #006H
MOV 36H, #007H
MOV 37H, #008H
MOV 38H, #009H
MOV 39H, #00AH
MOV 3AH, #00BH
MOV 3BH, #00CH
MOV 3CH, #00DH
MOV 3DH, #00EH
MOV 3EH, #00FH
MOV 3FH, #010H

SJMP ORTALAMA

ORTALAMA:
MOV R0,#30H
MOV A,30H
CLR C

DONGU:
INC R0
ADD A,@R0
JNC DEVAM
INC 41H
CLR C

DEVAM:
CJNE R0,#3FH,DONGU
MOV 40H,A

BOLME:

MOV A,40H
ANL A,#0FH
MOV 60H,A

MOV A,40H
ANL A,#0F0H
SWAP A
MOV 61H,A

MOV A,41H
SWAP A
ADD A,61H
MOV 61,A	

SON:
SJMP SON

END