# Keil uVision project mantıksal_islemler_karışık_soru.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: mantıksal_islemler_karışık_soru
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 mantıksal_islemler_karisik_soru.a51
