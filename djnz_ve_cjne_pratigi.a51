ORG 00H
	START:
	MOV 30H,#25
	MOV 31H,#49
	MOV 32H,#50
	MOV 33H,#51
	MOV 34H,#75
	MOV R7,#5
	MOV R0,#30H
	
	SJMP DONGU
	
	DONGU:
	MOV A,@R0
	
	CJNE A,#50,KONTROL
	
	SJMP DEVAM
	
	
	KONTROL:
	JC BOZUK_VERI

	SJMP DEVAM
	
	BOZUK_VERI:
	MOV @R0,#00H
	SJMP DEVAM
	
	DEVAM:
	INC R0
	DJNZ R7,DONGU
	
	BITIS:
	  SJMP BITIS
END
	
	
	
	