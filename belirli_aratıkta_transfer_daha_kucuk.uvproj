# Keil uVision project belirli_aratıkta_transfer_daha_kucuk.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: belirli_aratıkta_transfer_daha_kucuk
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 belirli_aralık_transfer_daha_kucuk.a51
