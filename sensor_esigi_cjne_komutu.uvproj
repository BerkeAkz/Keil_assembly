# Keil uVision project sensor_esigi_cjne_komutu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: sensor_esigi_cjne_komutu
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 cjne_komutu_sensor_sorusu.a51
