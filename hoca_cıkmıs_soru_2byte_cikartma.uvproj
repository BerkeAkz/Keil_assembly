# Keil uVision project hoca_cıkmıs_soru_2byte_cikartma.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: hoca_cıkmıs_soru_2byte_cikartma
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 2byte_cikartma.a51
