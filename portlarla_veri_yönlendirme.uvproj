# Keil uVision project portlarla_veri_yönlendirme.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: portlarla_veri_yönlendirme
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 portlarla_veri_yonlendirme.a51
