# Keil uVision project led_uygulaması_delay_kullanarak.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: led_uygulaması_delay_kullanarak
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 detay_kullanarak_led_uygulaması.a51
